# Keil uVision project STM32F107.uvprojx, settings and files
target STM32_MCU0 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F107 +hex
  c flags: Optim=3 uC99=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER,TINYSH_RTOS
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\user;..\STM32F107\fwlib\inc;..\STM32F107\hardware;..\STM32F107\system;..\STM32F107\system\core;..\STM32F107\system\delay;..\STM32F107\system\sys;..\..\..\tinysh\include;..\3rdparty\csl\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: main.c task_run.c
    ../../../tinysh/include/tsh_main/: shell.c tsh_config.h
  group hardware
    ../STM32F107/hardware/: usart.c
  group system
    ../STM32F107/system/: stm32f10x_it.c system_stm32f10x.c
    ../STM32F107/system/sys/: sys.c
    ../STM32F107/system/delay/: delay.c
    ../STM32F107/system/core/: core_cm3.c startup_stm32f107xc.s
  group stmlib
    ../STM32F107/fwlib/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_gpio.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group 3rdparty
    ../3rdparty/csl/include/csl/: cs_linked_hash_map.o cs_list.o cs_memwriter.o cs_object_pool.o
  group tinysh
    ../../../tinysh/include/kmq/: kmq.c kmq.h
    ../../../tinysh/include/tinysh/: cli_cmd.c cli_cmd.h tinysh.c tinysh.h
